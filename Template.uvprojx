# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Public;.\APP\led;.\APP\24Cxx;.\APP\beep;.\App\flash;.\App\iic;.\App\key;.\APP\tftlcd;.\App\spi;.\App\sram;.\App\tim;.\App\touch;.\App\rtc;.\App\ds18b20;.\Malloc;.\EMWIN\STemWin\Config;.\EMWIN\STemWin\inc;.\App\smg;.\EMWIN\Demo;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III;.\UCOSIII\UCOS_BSP;.\UCOSIII\uCOS_CONFIG;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\User\inc;.\User\src\Main;.\User\src\InitialTask;.\User\src\DrawComp;.\User\src\CtrlTask
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group APP
    ./APP/24Cxx/: 24cxx.c
    ./APP/flash/: flash.c
    ./APP/iic/: iic.c
    ./APP/led/: led.c
    ./APP/spi/: spi.c
    ./APP/sram/: sram.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/time/: time.c
    ./APP/touch/: touch.c
    ./APP/key/: key.c
    ./APP/rtc/: rtc.c
    ./APP/ds18b20/: ds18b20.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Malloc
    ./Malloc/: malloc.c
  group UCOSIII_BSP
    ./UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ./UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group EMWIN_CONFIG
    ./EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ./EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ./EMWIN/STemWin/Lib/: STemWin526_CM3_OS_Keil.lib
  group EMWIN_DEMO
    ./EMWIN/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Main
    ./User/src/Main/: main.c stm32f10x_it.c
  group InitialTask
    ./User/src/InitialTask/: InitialTask.c
  group CtrlTask
    ./User/src/CtrlTask/: CtrlTask.c
  group DrawComp
    ./User/src/DrawComp/: DrawComp.c
